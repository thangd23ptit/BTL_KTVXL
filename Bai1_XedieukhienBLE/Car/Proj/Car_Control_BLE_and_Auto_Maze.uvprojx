# Keil uVision project Car_Control_BLE_and_Auto_Maze.uvprojx, settings and files
target Project (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Car_Control_BLE_and_Auto_Maze
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER STM3210X_MD
  c include: ..\Application;..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\STM32F10x_StdPeriph_Driver\src;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport;..\Inc\Ip;..\Inc\Middleware;..\Inc\Application;..\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ../Src/: system_init.c main.c
    ../Src/Application/: app_bluetooth.c app_control.c app_gpio.c app_line_sensor.c app_maze.c app_mode.c app_motor.c app_pwm.c app_sensor.c app_timer.c app_uart.c
    ../Src/Ip/: ip_bluetooth.c ip_control.c ip_gpio.c ip_line_sensor.c ip_maze.c ip_mode.c ip_motor.c ip_pwm.c ip_sensor.c ip_timer.c ip_uart.c
    ../Src/MIddlewere/: mid_bluetooth.c mid_control.c mid_gpio.c mid_line_sensor.c mid_maze.c mid_mode.c mid_motor.c mid_pwm.c mid_sensor.c mid_timer.c mid_uart.c
  group Inc
    ../Inc/: system_init.h
    ../Inc/Application/: app_bluetooth.h app_control.h app_gpio.h app_line_sensor.h app_maze.h app_mode.h app_motor.h app_pwm.h app_sensor.h app_timer.h app_uart.h
    ../Inc/Ip/: ip_bluetooth.h ip_control.h ip_gpio.h ip_line_sensor.h ip_maze.h ip_mode.h ip_motor.h ip_pwm.h ip_sensor.h ip_timer.h ip_uart.h
    ../Inc/Middleware/: mid_bluetooth.h mid_control.h mid_gpio.h mid_line_sensor.h mid_maze.h mid_mode.h mid_motor.h mid_pwm.h mid_sensor.h mid_timer.h mid_uart.h
  group Lib
    ../Lib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
