# Keil uVision project Gamepad.uvprojx, settings and files
target Gamepad (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Gamepad
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER STM3210X_MD
  c include: ..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\STM32F10x_StdPeriph_Driver\src;..\Inc;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport;..\Src;..\Inc\Application;..\Inc\Ip;..\Inc\MIddleware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ../Src/: main.c
    ../Src/Application/: app_adc.c app_bluetooth.c app_gamepad.c app_gpio.c app_joystick.c app_mode.c app_protocol.c app_systick.c app_tim.c app_uart.c
    ../Src/Ip/: ip_adc.c ip_bluetooth.c ip_gamepad.c ip_gpio.c ip_joystick.c ip_mode.c ip_protocol.c ip_systick.c ip_tim.c ip_uart.c
    ../Src/MIddleware/: mid_adc.c mid_bluetooth.c mid_gamepad.c mid_gpio.c mid_joystick.c mid_mode.c mid_protocol.c mid_systick.c mid_tim.c mid_uart.c
  group Inc
    ../Inc/: main.h
    ../Inc/Application/: app_adc.h app_bluetooth.h app_gamepad.h app_gpio.h app_joystick.h app_mode.h app_protocol.h app_systick.h app_tim.h app_uart.h
    ../Inc/Ip/: ip_adc.h ip_bluetooth.h ip_gamepad.h ip_gpio.h ip_joystick.h ip_mode.h ip_protocol.h ip_systick.h ip_tim.h ip_uart.h
    ../Inc/MIddleware/: mid_adc.h mid_bluetooth.h mid_gamepad.h mid_gpio.h mid_joystick.h mid_mode.h mid_protocol.h mid_systick.h mid_tim.h mid_uart.h
  group Lib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Lib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
